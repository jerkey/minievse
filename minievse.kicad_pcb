# Repository jerkey/minievse

File README.md:

# miniEVSE
##Electric Vehicle Safety Equipment

README.md for miniEVSE Hardware
Files .pro .sch and .kicad_pcb in KiCAD format
License CC BY-SA 3.0
miniEVSE Hardware

Inspired by OpenEVSE_PLUS project at https://github.com/OpenEVSE/OpenEVSE_PLUS/

## KiCad design minievse.kicad_pcb

Parts:
C1, C2, C4, C6: 104; C_Disc_D3_P2.5
C3, C5: 100uF; C_Radial_D7.5_L11.2_P2.5
C7, C8, C9, C10: 1uF; C_Radial_D5_L6_P2.5
C11, C12, C13, C14: 10uF; C_Radial_D5_L6_P2.5
C15: C
D1, D2: 1N4007; Diode_DO-41_SOD81_Horizontal_RM10
D3: P6KE16CA; Diode_DO-41_SOD81_Horizontal_RM10
D6: 1N4148; Diode_DO-35_SOD27_Horizontal_RM10
IC1: ATMEGA328P-P; DIP-28_W7.62mm_LongPads
P1: SERIAL; Pin_Header_Straight_1x06
P2: 5V input; CCFLHV
P3: ICSP; Pin_Header_Straight_2x03
P4: Pilot; PINHEAD1-3
P5: AC_GND_AC; bornier3
P6: LED_STRIP; PINHEAD1-3
P7: RELAY_COIL; CCFLHV
R1: 220; Resistor_Horizontal_RM10mm
R2, R10, R18: 10K; Resistor_Horizontal_RM10mm
R3: 1K; Resistor_Horizontal_RM10mm
R4, R8, R9, R11: 2550; Resistor_Horizontal_RM10mm
R5: 56K; Resistor_Horizontal_RM10mm
R6: 100K; Resistor_Horizontal_RM10mm
R7: 200K; Resistor_Horizontal_RM10mm
R12, R13: 1200; Resistor_Horizontal_RM10mm
R14, R15: 50K; Resistor_Horizontal_RM10mm
R16, R17: 15K; Resistor_Horizontal_RM10mm
R19: R
RV1: POT; Potentiometer_Triwood_RM-065
SW1: RESET_BUTTON; SW-1825027-5
U1: MAX232; DIP-16_W7.62mm_LongPads
U2: MOC3021M; DIP-6_W7.62mm_LongPads
U3: H11AA; DIP-6_W7.62mm_LongPads
X1: 16MHz; HC-49V-OR-RESONATOR

Connections:
+5VD: C3.1, C4.1, C5.1, C6.1, IC1.7 (VCC), IC1.20 (AVCC), P1.3, P2.2, P3.2, P6.3, R3.2, R5.1, R10.1, R18.1, RV1.3, U1.16
/AC_SENSE_1: C11.1, IC1.27 ((PCINT12/SDA/ADC4)PC4), R4.1, R9.2
/AC_SENSE_2: C12.1, IC1.28 ((PCINT13/SCL/ADC5)PC5), R8.1, R11.2
/AC_ZEROX: IC1.4 ((PCINT18/INT0)PD2), R18.2, U3.5
/AMP_KNOB: IC1.23 ((PCINT8/ADC0)PC0), RV1.2
/LED_DATA: IC1.6 ((PCINT20/XCK/T0)PD4), P6.2
/PILOT: D3.2, P4.2, R7.1, R12.1, R13.1
/PILOTREAD: IC1.24 ((PCINT9/ADC1)PC1), R5.2, R6.1, R7.2
/PP: P4.1, R2.2, R3.1
/PP_READ: D6.1 (K), IC1.25 ((PCINT10/ADC2)PC2), R2.1
/PWM: IC1.16 ((PCINT2/OC1B/~SS~)PB2), U1.10, U1.11
/RELAY_TRIAC: IC1.15 ((PCINT1/OC1A)PB1), R1.2
/RX: IC1.2 ((PCINT16/RXD)PD0), P1.4
/TX: IC1.3 ((PCINT17/TXD)PD1), P1.5
/miso: IC1.18 ((PCINT4/MISO)PB4), P3.1
/mosi: IC1.17 ((PCINT3/OC2A/MOSI)PB3), P3.4
/reset: C1.1, IC1.1 ((PCINT14/~RESET~)PC6), P3.5, R10.2, SW1.1
/sck: IC1.19 ((PCINT5/SCK)PB5), P3.3
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, D3.1, D6.2 (A), IC1.8 (GND), IC1.22 (GND), P1.2, P2.1, P3.6, P4.3, P5.2, P6.1, R4.2, R6.2, R8.2, RV1.1, SW1.2, U1.15, U2.2, U3.4, X1.3 (gnd)
unnamed: C1.2, P1.6
unnamed: C2.1, IC1.21 (AREF)
unnamed: C7.1, U1.1
unnamed: C7.2, U1.3
unnamed: C8.1, U1.4
unnamed: C8.2, U1.5
unnamed: C9.1, U1.2
unnamed: C10.2, U1.6
unnamed: C13.1, R9.1, R14.1
unnamed: C14.1, R11.1, R15.1
unnamed: C15.1, D2.2 (A), P5.1, P7.1, R17.2
unnamed: C15.2, R19.1
unnamed: D1.1 (K), R14.2
unnamed: D1.2 (A), P5.3, R16.2, U2.6
unnamed: D2.1 (K), R15.2
unnamed: IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), X1.2
unnamed: IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), X1.1
unnamed: P7.2, R19.2, U2.4
unnamed: R1.1, U2.1
unnamed: R12.2, U1.7
unnamed: R13.2, U1.14
unnamed: R16.1, U3.2
unnamed: R17.1, U3.1

Notes on the sheet:
+5 Volts
THIS CONNECTOR TO BIG 50A RELAY WITH 120V COIL
a word on triacs controlling inductive loads: http://www.instructables.com/id/Arduino-controlled-light-dimmer-The-circuit/step2/A-word-on-inductive-loads-theory/
coil snubber

Board: 2 copper layers, 101.6 x 50.8 mm, 50 parts (0 on the bottom side), 41 nets.

## Code that names these connections

File src/minievse.ino:

#define AC_ZEROX        2  // PCINT18/INT0/PD2 DIP pin pin 4, digital 2
#define AC_ZEROX_INT    0  // PCINT18/INT0/PD2 DIP pin pin 4, digital 2
// #define RELAY_TRIAC 3  // PCINT19/0C2B/INT1/PD3 DIP pin pin 5, digital 3
#define RELAY_TRIAC     9  // PCINT1/OC1A/PB1 DIP pin 15, digital 9
#define AMP_KNOB        A0 // this knob sets EVSE current available signal
#define PILOTREAD       A1
#define PP_READ         A2
#define AC_SENSE_1      A4 // measures the voltage on leg 1 of the AC
#define AC_SENSE_2      A5 // measures the voltage on leg 2 of the AC
#define LED_DATA        6 // PCINT22/0C0A/AIN0/PD6 DIP pin 12, digital 6

#include <avr/io.h>
#include <avr/interrupt.h>
#define TRIAC_PULSEWIDTH 4   //trigger pulse width (counts)

void setup() {
  Serial.begin(57600);
  Serial.println("minievse v1.0");
  pinMode(RELAY_TRIAC,OUTPUT);
}

void loop() {
  Serial.print("AC 1: ");
  Serial.print(analogRead(AC_SENSE_1));
  Serial.print("     AC 2: ");
  Serial.print(analogRead(AC_SENSE_2));
  Serial.print("     AMP_KNOB: ");
  Serial.print(analogRead(AMP_KNOB));
  delay(100);
}

void initTriacTimer() {
// Relay Coil Triac Control Timing Sequence
// * timer is set up but disabled
// * zero crossing detected on pin 2
// * timer starts counting from zero
// * comparator set to "delay to on" value
// * counter reaches comparator value
// * comparator ISR turns on triac gate
// * counter set to overflow - pulse width
// * counter reaches overflow
// * overflow ISR truns off triac gate
// * triac stops conducting at next zero cross

// The hardware timer runs at 16MHz. Using a
// divide by 256 on the counter each count is
// 16 microseconds.  1/2 wave of a 60Hz AC signal
// is about 520 counts (8,333 microseconds).

  //(see ATMEGA 328 data sheet pg 134 for more details)
  OCR1A = 100;      //initialize the comparator
  TIMSK1 = 0x03;    //enable comparator A and overflow interrupts
  TCCR1A = 0x00;    //timer control registers set for
  TCCR1B = 0x00;    //normal operation, timer disabled
  //IRQ0 is pin 2. Call zeroCrossingInterrupt
  attachInterrupt(0,zeroCrossingInterrupt, FALLING);
}

//Interrupt Service Routines
void zeroCrossingInterrupt(){ //zero cross detect
  TCCR1B=0x04; //start timer with divide by 256 input
  TCNT1 = 0;   //reset timer - count from zero
}

ISR(TIMER1_COMPA_vect){ //comparator match
  digitalWrite(RELAY_TRIAC,HIGH);  //set triac gate to high
  TCNT1 = 65536-TRIAC_PULSEWIDTH;      //trigger pulse width
}

ISR(TIMER1_OVF_vect){ //timer1 overflow
  digitalWrite(RELAY_TRIAC,LOW); //turn off triac gate
  TCCR1B = 0x00;          //disable timer stopd unintended triggers
}

void setRelayState(boolean relayState) {

int i=483;

OCR1A = i;     //set the compare register brightness desired.
if (i<65){i=483;}
delay(15);

}

## Commit log

2016-04-19 first commit of tinyevse
2016-04-19 add ICSP programming connector
2016-04-19 add a lot of stuff, move PWM pin
2016-04-19 add a datasheet, schematic, and README.md
2016-04-19 annotate and add proper footprints to all but relay
2016-04-19 board is well underway
2016-04-19 add a picture of the board as it stands
2016-04-19 had the wrong footprint for 104 capacitors
2016-04-20 add arbduino-cache.lib
2016-04-20 add battery-dlg.mod
2016-04-20 add 2-pin connector for external relay coil
2016-04-22 switch driver chip to make bipolar pilot signal
2016-04-22 tinyevse renamed to minievse
2016-04-23 update schematic
2016-04-25 replace relays with triacs, update schematic
2016-04-25 fix U1 wiring, choose a part for D3
2016-05-01 inductor control of big relay
2016-05-02 sense AC voltage, dim relay coil, LED strip, amp knob
2016-05-02 first version of embedded software
2016-05-02 replace zero crossing opto, assign footprints
2016-05-02 placed parts on the board, ready for traces
2016-05-02 add AC Phase control for relay coil current to code
2016-05-02 c10 polarized cap was backwards
2016-05-03 move reference designators to inside part outlines
2016-05-03 automate the taking of screenshots for board and schematic
2016-05-03 board half done
2016-05-05 move things around for mounting holes in corners
2016-05-10 add mounting holes, run more traces
2016-05-10 change LED pin from 12 to 6 for wiring convenience
2016-05-10 finish wiring up board traces
2016-05-10 rm max232, use bipolar +-12v supply and op-amp
2016-06-05 add -cache.lib and whatever else i was doing
